# Keil uVision project TCore.uvprojx, settings and files
target TCore (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.10.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TCore +hex
  AfterMake: find "Total R" ./Listings/TCore.map
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F401xE,BLUENRG_MS,ENABLE_SPI_FIX
  c misc: --C99 --gnu
  c include: ../source/Inc;../source/Drivers/STM32F4xx_HAL_Driver/Inc;../source/Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../source/Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../source/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../source/Drivers/CMSIS/Include;../source/Drivers/CMSIS/Device/ST/STM32F4xx/Include;../source/Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../source/Middlewares/Third_Party/FreeRTOS/Source/include;../source/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../source/Middlewares/Third_Party/FatFs/src/drivers;../source/Middlewares/Third_Party/FatFs/src;../source/Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/includes;../source/Drivers/Components;../source/Src/shell;../source/Src;..\source\Middlewares\Arithmetic
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../source/Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Application/MDK-ARM
    ../source/Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f401xe.s
  group Application/User
    ../source/Src/: main.c usbd_desc.c usb_device.c usbd_cdc_if.c stm32f4xx_hal_msp.c usbd_conf.c stm32f4xx_it.c freertos.c fatfs.c bsp_driver_sd.c bluenrg_service.c bluenrg_sensor_service.c bluenrg_remotecontrol_service.c core_temperature.c userInterface.c system_control.c
    ../source/Inc/: platform.h stm32f4xx_hal_conf.h FreeRTOSConfig.h
  group Bsp
    ../source/Src/: bluenrg_interface.c bsp.c clock.c bsp_hum_temp.c bsp_pressure.c bsp_rtc_calendar.c bsp_imu_6axes.c bsp_led.c bsp_key.c bsp_temperature.c bsp_battery_detect.c
  group Shell
    ../source/Src/shell/: fatfs_shell.c Log.c rtc_shell.c shell.c
  group Drivers
    ../source/Drivers/Components/: hts221.c lps25h.c lps25hb.c lsm6ds3.c ads1118.c
  group Drivers/STM32F4xx_HAL_Driver
    ../source/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dsi.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_lptim.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_usb.c
  group Middlewares/USB_Device_Library
    ../source/Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ioreq.c usbd_core.c usbd_ctlreq.c
    ../source/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Middlewares/FreeRTOS
    ../source/Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../source/Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../source/Middlewares/Third_Party/FreeRTOS/Source/: timers.c event_groups.c queue.c list.c tasks.c croutine.c
    ../source/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/FatFs
    ../source/Middlewares/Third_Party/FatFs/src/: ff.c diskio.c ff_gen_drv.c
    ../source/Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
    ../source/Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
  group Middlewares/BlueBRG
    ../source/Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/hci/: hci.c
    ../source/Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/hci/controller/: bluenrg_gap_aci.c bluenrg_gatt_aci.c bluenrg_hal_aci.c bluenrg_l2cap_aci.c bluenrg_utils_small.c
    ../source/Middlewares/ST/STM32_BlueNRG/Interface/: bluenrg_itf_template.c
    ../source/Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/utils/: bluenrglist.c gp_timer.c osal.c
  group Middlewares/Arithmetic
    ../source/Middlewares/Arithmetic/: alg_temperature.c
  group Doc
    ../source/: readme.txt
